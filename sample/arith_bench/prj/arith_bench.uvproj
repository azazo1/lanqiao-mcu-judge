# Keil uVision project arith_bench.uvproj, settings and files
target arith_bench (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: arith_bench +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
