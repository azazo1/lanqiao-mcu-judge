# Keil uVision project us.uvproj, settings and files
target us (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: us +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user;../src/driver
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
  group driver
    ../src/driver/: init.c init.h seg.c seg.h us.c us.h utils.c utils.h key.c key.h
