# Keil uVision project persistent_state.uvproj, settings and files
target persistent_state (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: persistent_state +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user;../src/driver
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
  group driver
    ../src/driver/: init.c init.h key.c key.h led.c led.h seg.c seg.h utils.c utils.h ds18b20.c ds18b20.h iic.c iic.h eeprom.c eeprom.h
