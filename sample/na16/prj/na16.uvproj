# Keil uVision project na16.uvproj, settings and files
target na16 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: na16 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user;../src/driver
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
  group driver
    ../src/driver/: ds18b20.c ds18b20.h ds1302.c ds1302.h iic.c iic.h init.c init.h key.c key.h led.c led.h onewire.c onewire.h pcf8591.c pcf8591.h seg.c seg.h uart.c uart.h utils.c utils.h us.c us.h
