# Keil uVision project eeprom_rw.uvproj, settings and files
target eeprom_rw (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: eeprom_rw +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user;../src/driver
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
  group driver
    ../src/driver/: eeprom.c eeprom.h iic.c iic.h utils.c utils.h
