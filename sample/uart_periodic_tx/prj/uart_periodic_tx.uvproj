# Keil uVision project uart_periodic_tx.uvproj, settings and files
target uart_periodic_tx (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: uart_periodic_tx +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user;../src/driver
  group user
    ./: STARTUP.A51
    ../src/user/: periodic_main.c
  group driver
    ../src/driver/: init.c init.h seg.c seg.h uart.c uart.h utils.c utils.h
