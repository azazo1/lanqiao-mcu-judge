# Keil uVision project ds18b20.uvproj, settings and files
target ds18b20 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/driver;../src/user
  group driver
    ./: STARTUP.A51
    ../src/driver/: init.c init.h key.c key.h led.c led.h seg.c seg.h utils.c utils.h ds18b20.c ds18b20.h onewire.c onewire.h
  group user
    ../src/user/: main.c
