# Keil uVision project na14.uvproj, settings and files
target Test (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: na14 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ../src/user/: main.c
  group Driver
    ../src/driver/: DAC.c DAC.h ds18b20.c ds18b20.h Key.c Key.h LED.c LED.h Seg.c Seg.h Wave.c Wave.h Init.h Init.c
