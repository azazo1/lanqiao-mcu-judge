# Keil uVision project pa14.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1655xxxx +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ../Driver/: init.c init.h ds18b20.c ds18b20.h ds1302.c ds1302.h iic.c iic.h led.c led.h seg.c seg.h key.c key.h
  group User
    ./: main.c
