# Keil uVision project pa15-2.uvproj, settings and files
target demo (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pa15-2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\driver
  group user
    ../src/user/: main.c STARTUP.A51
  group driver
    ../src/driver/: init.c key.c led.c seg.c iic.c filtering.c onewire.c
