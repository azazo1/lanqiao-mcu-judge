# Keil uVision project uart_multi_ti_isr.uvproj, settings and files
target uart_multi_ti_isr (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: uart_multi_ti_isr +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/driver;../src/user
  group driver
    ./: STARTUP.A51
    ../src/driver/: init.c init.h seg.c seg.h uart.c uart.h utils.c utils.h
  group user
    ../src/user/: main.c
