# Keil uVision project pa13-2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pa13-2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ../src/user/: main.c
  group Driver
    ../src/driver/: init.h init.c iic.c iic.h led.c led.h seg.c seg.h wave.c wave.h key.c key.h
