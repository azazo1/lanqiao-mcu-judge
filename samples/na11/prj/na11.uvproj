# Keil uVision project na11.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: na11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ../src/user/: main.c
  group Driver
    ../src/driver/: Init.c Init.h ds18b20.c ds18b20.h ds1302.c ds1302.h iic.c iic.h Key.c Key.h Led.c Led.h Seg.c Seg.h
