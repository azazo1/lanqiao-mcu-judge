# Keil uVision project pa16-1.uvproj, settings and files
target code (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pa16-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ../src/driver/: init.c init.h ds18b20.c ds18b20.h iic.c iic.h key.c key.h led.c led.h wave.c wave.h seg.h seg.c
  group User
    ./: STARTUP.A51
    ../src/user/: main.c
