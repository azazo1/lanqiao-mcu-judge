# Keil uVision project key_seg_btn.uvproj, settings and files
target key_seg_btn (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: key_seg_btn +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user;../src/driver
  group driver
    ./: STARTUP.A51
    ../src/driver/: init.c init.h key.c key.h led.c led.h seg.c seg.h utils.c utils.h
  group user
    ../src/user/: main.c
