# Keil uVision project ad_da.uvproj, settings and files
target ad_da (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ad_da +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../src/user;../src/driver
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
  group driver
    ../src/driver/: iic.c iic.h init.c init.h key.c key.h pcf8591.c pcf8591.h seg.c seg.h utils.c utils.h
